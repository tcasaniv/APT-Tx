options:
  parameters:
    author: tcasaniv
    generate_options: qt_gui
    id: simulate_fm
    output_language: python
    title: simulate_fm
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '11025'
  states: {}
- name: fm_rate
  id: variable
  parameters:
    value: audio_rate*3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volumen
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: wav_path
  id: variable
  parameters:
    value: wavfile
  states: {}
- name: analog_nbfm_rx
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 17e3
    quad_rate: fm_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 17e3
    quad_rate: fm_rate
    tau: '75e-6'
  states: {}
- name: audio_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {}
- name: audio_gui_time_sink
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '2048'
    srate: audio_rate
    type: float
    update_time: '0.01'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: control_volume
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: detect_platform
  id: epy_module
  parameters:
    source_code: |-
      import platform
      from pathlib import Path

      APP_FILES_DIR_NAME = "APT-Tx_Files"

      def get_app_files_dir():
          """Obtiene la ruta a la carpeta de archivos de la aplicación y la crea si no existe."""
          if platform.system() == "Windows":
              base_path = Path(os.environ['USERPROFILE']) / 'Documents'
          else:
              base_path = Path.home()
          
          app_dir = base_path / APP_FILES_DIR_NAME
          app_dir.mkdir(parents=True, exist_ok=True)
          return str(app_dir)

      output_filename = f"apt_generated_audio.wav"
      generated_file_path = str(Path(get_app_files_dir()) / output_filename)
      wav_path = generated_file_path

      print(wav_path)
  states: {}
- name: fm_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: fm_rate*2
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    type: complex
  states: {}
- name: rational_resampler
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: ccc
  states: {}
- name: throttle_audio_gui
  id: blocks_throttle2
  parameters:
    samples_per_second: audio_rate
    type: float
  states: {}
- name: throttle_fm_gui
  id: blocks_throttle2
  parameters:
    samples_per_second: fm_rate*2
    type: complex
  states: {}
- name: virtual_SDR_Rx
  id: virtual_source
  parameters:
    stream_id: virtual_SDR
  states: {}
- name: virtual_SDR_Tx
  id: virtual_sink
  parameters:
    stream_id: virtual_SDR
  states: {}
- name: wavfile
  id: parameter
  parameters:
    label: wavfile
    short_id: f
    type: str
    value: detect_platform.wav_path
  states: {}
- name: wavfile_source
  id: blocks_wavfile_source
  parameters:
    file: wav_path
    repeat: 'True'
  states: {}

connections:
- [analog_nbfm_rx, '0', audio_sink, '0']
- [analog_nbfm_rx, '0', throttle_audio_gui, '0']
- [analog_nbfm_tx, '0', rational_resampler, '0']
- [analog_nbfm_tx, '0', virtual_SDR_Tx, '0']
- [control_volume, '0', analog_nbfm_tx, '0']
- [rational_resampler, '0', throttle_fm_gui, '0']
- [throttle_audio_gui, '0', audio_gui_freq_sink, '0']
- [throttle_audio_gui, '0', audio_gui_time_sink, '0']
- [throttle_fm_gui, '0', fm_gui_freq_sink, '0']
- [virtual_SDR_Rx, '0', analog_nbfm_rx, '0']
- [wavfile_source, '0', control_volume, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
