options:
  parameters:
    author: tcasaniv
    generate_options: qt_gui
    id: transmit_sdr
    output_language: python
    title: Transmisión con/sin SDR
  states: {}

blocks:
- name: activate_amp
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,2,1
    label: Amplificador Tx (Solo HackRF)
    label0: Desactivado
    label1: Activado (+11 dB)
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: fm_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,0,1,1
    lbl: Frecuencia de transmisión
    maxFreqHz: 6e9
    minFreqHz: 1e6
    value: freq_sdr
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,2
    label: Ganancia
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
  states: {}
- name: max_deviation
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Máxima Desviación FM
    start: 2.5e3
    step: 0.5e3
    stop: fm_rate/2
    value: 17e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,2
    label: '"Volumen\nAudio Fuente"'
    start: '0'
    step: '1'
    stop: '300'
    value: '100'
  states: {}
- name: wav_path
  id: variable
  parameters:
    comment: Ruta del archivo WAV
    value: wavfile
  states: {}
- name: analog_nbfm_rx
  id: analog_nbfm_rx
  parameters:
    audio_rate: '12000'
    max_dev: max_deviation
    quad_rate: int(fm_rate)
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_tx
  id: analog_nbfm_tx
  parameters:
    audio_rate: '12000'
    fh: '-1.0'
    max_dev: max_deviation
    quad_rate: int(fm_rate)
    tau: '75e-6'
  states: {}
- name: audio_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: '12000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab_widget@0:[0,0,1,4]
    label: Ganancia Relativa
    label1: '"APT\n(imagen\n en AM)"'
    name: '"Espectro de la señal Automatic Picture Transmission (APT)"'
    type: float
  states: {}
- name: audio_gui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fm_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab_widget@1:[0,0,1,4]
    label: Ganancia Relativa
    label1: '"Señal APT\nmodulada\nen FM"'
    name: '"Espectro de la señal APT modulada en FM"'
    type: complex
  states: {}
- name: audio_rational_resampler
  id: rational_resampler_xxx
  parameters:
    decim: '11025'
    interp: '12000'
    type: fff
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '12000'
  states: {state: disabled}
- name: control_volume
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: detect_platform
  id: epy_module
  parameters:
    source_code: |-
      import platform
      import os

      APP_FILES_DIR_NAME = "APT-Tx_Files"

      def get_app_files_dir():
          """Obtiene la ruta a la carpeta de archivos de la aplicación y la crea si no existe."""
          if platform.system() == "Windows":
              base_path = os.path.join(os.environ['USERPROFILE'], 'Documents')
          else:
              base_path = os.path.expanduser("~")
          
          app_dir = os.path.join(base_path, APP_FILES_DIR_NAME)
          os.makedirs(app_dir, exist_ok=True)
          return app_dir

      output_filename = "apt_generated_audio.wav"
      generated_file_path = os.path.join(get_app_files_dir(), output_filename)
      wav_path = generated_file_path

      print(wav_path)
  states: {}
- name: fm_rational_resampler
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_rate)
    interp: int(samp_rate_sdr)
    type: ccc
  states: {}
- name: freq_sdr
  id: parameter
  parameters:
    label: Frecuencia TX SDR
    type: eng_float
    value: 928e6
  states: {}
- name: qtgui_time_sink_audio
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: tab_widget@0:[1,0,1,4]
    label1: '"Audio APT\ngenerado"'
    size: '512'
    srate: '12000'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Amplitud
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fm_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab_widget@1:[1,0,1,4]
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate_sdr
    fc: freq
    fftsize: '1024'
    gui_hint: tab_widget@2:[1,0,1,4]
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '12000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: tab_widget@0:[2,0,2,4]
    type: float
  states: {}
- name: samp_rate_sdr
  id: parameter
  parameters:
    label: Frecuencia de muestro TX SDR
    type: eng_float
    value: 1e6
  states: {}
- name: sdr_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_sdr
    ctrlpanel: 'True'
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab_widget@2:[0,0,1,4]
    label: Ganancia Relativa
    label1: '"Señal APT \nmodulada\nen FM"'
    name: '"Espectro de la señal transmitiéndose con SDR"'
    type: complex
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: freq
    gain: (56*gain)+17
    samp_rate: samp_rate_sdr
    type: fc32
  states: {state: disabled}
- name: soapy_hackrf_sink
  id: soapy_hackrf_sink
  parameters:
    amp: activate_amp
    center_freq: freq
    samp_rate: samp_rate_sdr
    type: fc32
    vga: 47*gain
  states: {state: disabled}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: freq
    gain: (76*gain)-12
    samp_rate: samp_rate_sdr
    type: fc32
  states: {state: disabled}
- name: soapy_plutosdr_sink_0
  id: soapy_plutosdr_sink
  parameters:
    center_freq: freq
    gain: 89*gain
    samp_rate: samp_rate_sdr
    type: fc32
  states: {state: disabled}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,4,4
    label0: APT generado
    label1: APT Modulado en FM
    label2: Señal transmitiéndose por el SDR
    num_tabs: '3'
  states: {}
- name: throttle_fm
  id: blocks_throttle2
  parameters:
    samples_per_second: fm_rate
    type: complex
  states: {}
- name: throttle_sdr_gui
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_sdr
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate_sdr
    sync: sync
    type: fc32
  states: {state: disabled}
- name: wavfile
  id: parameter
  parameters:
    label: Ruta archivo WAV
    type: str
    value: detect_platform.wav_path
  states: {}
- name: wavfile_source
  id: blocks_wavfile_source
  parameters:
    file: wav_path
    repeat: 'False'
  states: {}

connections:
- [analog_nbfm_rx, '0', audio_sink, '0']
- [analog_nbfm_tx, '0', analog_nbfm_rx, '0']
- [analog_nbfm_tx, '0', fm_rational_resampler, '0']
- [analog_nbfm_tx, '0', throttle_fm, '0']
- [audio_rational_resampler, '0', analog_nbfm_tx, '0']
- [audio_rational_resampler, '0', audio_gui_freq_sink, '0']
- [audio_rational_resampler, '0', qtgui_time_sink_audio, '0']
- [audio_rational_resampler, '0', qtgui_waterfall_sink_x_1, '0']
- [control_volume, '0', audio_rational_resampler, '0']
- [fm_rational_resampler, '0', soapy_bladerf_sink_0, '0']
- [fm_rational_resampler, '0', soapy_hackrf_sink, '0']
- [fm_rational_resampler, '0', soapy_limesdr_sink_0, '0']
- [fm_rational_resampler, '0', soapy_plutosdr_sink_0, '0']
- [fm_rational_resampler, '0', throttle_sdr_gui, '0']
- [fm_rational_resampler, '0', uhd_usrp_sink_0, '0']
- [throttle_fm, '0', audio_gui_freq_sink_0, '0']
- [throttle_fm, '0', qtgui_waterfall_sink_x_0, '0']
- [throttle_sdr_gui, '0', qtgui_waterfall_sink_x_0_0, '0']
- [throttle_sdr_gui, '0', sdr_gui_freq_sink, '0']
- [wavfile_source, '0', control_volume, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
