options:
  parameters:
    author: tcasaniv
    generate_options: qt_gui
    id: transmit_hackrf
    output_language: python
    title: transmit_hackrf
  states: {}

blocks:
- name: IF_hackrf_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: Ganancia IF TX
    start: '0'
    step: '1'
    stop: '47'
    value: '0'
  states: {}
- name: RF_hackrf_tx
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,4,2,1
    label: RF Amp TX
    label0: Desactivado
    label1: Activado (+11 dB)
    num_opts: '2'
    option0: 'False'
    option1: 'True'
    type: raw
    value: 'False'
    widget: radio_buttons
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '11025'
  states: {}
- name: fm_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,0,1,1
    lbl: Frecuencia de transmisión
    maxFreqHz: 6e9
    minFreqHz: 1e6
    value: freq_sdr
  states: {}
- name: max_deviation
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Máxima Desviación FM
    start: 2.5e3
    step: 0.5e3
    stop: fm_rate/2
    value: 17e3
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Volumen
    start: '0'
    step: '1'
    stop: '300'
    value: '50'
  states: {}
- name: wav_path
  id: variable
  parameters:
    comment: Ruta del archivo WAV
    value: wavfile
  states: {}
- name: analog_nbfm_rx
  id: analog_nbfm_rx
  parameters:
    audio_rate: '12000'
    max_dev: max_deviation
    quad_rate: int(fm_rate)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx
  id: analog_nbfm_tx
  parameters:
    audio_rate: '12000'
    fh: '-1.0'
    max_dev: max_deviation
    quad_rate: int(fm_rate)
    tau: '75e-6'
  states: {}
- name: audio_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: '12000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tab_widget@0
    label: Ganancia Relativa
    label1: '"APT\n(imagen\n en AM)"'
    name: '"Espectro de la señal Automatic Picture Transmission (APT)"'
    type: float
  states: {}
- name: audio_gui_freq_sink_0
  id: qtgui_freq_sink_x
  parameters:
    bw: fm_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab_widget@1
    label: Ganancia Relativa
    label1: '"Señal APT\nmodulada\nen FM"'
    name: '"Espectro de la señal APT modulada en FM"'
    type: complex
  states: {}
- name: audio_rational_resampler
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: '12000'
    type: fff
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '12000'
  states: {}
- name: control_volume
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: detect_platform
  id: epy_module
  parameters:
    source_code: |-
      import platform
      from pathlib import Path

      APP_FILES_DIR_NAME = "APT-Tx_Files"

      def get_app_files_dir():
          """Obtiene la ruta a la carpeta de archivos de la aplicación y la crea si no existe."""
          if platform.system() == "Windows":
              base_path = Path(os.environ['USERPROFILE']) / 'Documents'
          else:
              base_path = Path.home()
          
          app_dir = base_path / APP_FILES_DIR_NAME
          app_dir.mkdir(parents=True, exist_ok=True)
          return str(app_dir)

      output_filename = f"apt_generated_audio.wav"
      generated_file_path = str(Path(get_app_files_dir()) / output_filename)
      wav_path = generated_file_path

      print(wav_path)
  states: {}
- name: fm_rational_resampler
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_rate)
    interp: int(samp_rate_sdr)
    type: ccc
  states: {}
- name: freq_sdr
  id: parameter
  parameters:
    label: Frecuencia TX SDR
    type: eng_float
    value: 928e6
  states: {}
- name: samp_rate_sdr
  id: parameter
  parameters:
    label: Frecuencia de muestro TX SDR
    type: eng_float
    value: 8e6
  states: {}
- name: sdr_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_sdr
    ctrlpanel: 'True'
    fc: freq_sdr
    fftsize: '1024'
    grid: 'True'
    gui_hint: tab_widget@2
    label: Ganancia Relativa
    label1: '"Señal APT \nmodulada\nen FM"'
    name: '"Espectro de la señal transmitiéndose con HackRF"'
    type: complex
  states: {}
- name: soapy_hackrf_sink
  id: soapy_hackrf_sink
  parameters:
    amp: RF_hackrf_tx
    bandwidth: 1.75e6
    center_freq: freq
    samp_rate: samp_rate_sdr
    type: fc32
    vga: IF_hackrf_tx
  states: {state: disabled}
- name: tab_widget
  id: qtgui_tab_widget
  parameters:
    label0: APT generado
    label1: APT Modulado en FM
    label2: Señal transmitiéndose por el HackRF
    num_tabs: '3'
  states: {}
- name: throttle_fm_gui_1
  id: blocks_throttle2
  parameters:
    samples_per_second: fm_rate
    type: complex
  states: {}
- name: throttle_sdr_gui
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_sdr
    type: complex
  states: {}
- name: virtual_SDR_Rx
  id: virtual_source
  parameters:
    stream_id: virtual_SDR
  states: {}
- name: virtual_SDR_Tx
  id: virtual_sink
  parameters:
    stream_id: virtual_SDR
  states: {}
- name: wavfile
  id: parameter
  parameters:
    label: Ruta archivo WAV
    type: str
    value: detect_platform.wav_path
  states: {}
- name: wavfile_source
  id: blocks_wavfile_source
  parameters:
    file: wav_path
    repeat: 'True'
  states: {}

connections:
- [analog_nbfm_rx, '0', audio_sink, '0']
- [analog_nbfm_tx, '0', fm_rational_resampler, '0']
- [analog_nbfm_tx, '0', soapy_hackrf_sink, '0']
- [analog_nbfm_tx, '0', throttle_fm_gui_1, '0']
- [analog_nbfm_tx, '0', virtual_SDR_Tx, '0']
- [audio_rational_resampler, '0', analog_nbfm_tx, '0']
- [audio_rational_resampler, '0', audio_gui_freq_sink, '0']
- [control_volume, '0', audio_rational_resampler, '0']
- [fm_rational_resampler, '0', throttle_sdr_gui, '0']
- [throttle_fm_gui_1, '0', audio_gui_freq_sink_0, '0']
- [throttle_sdr_gui, '0', sdr_gui_freq_sink, '0']
- [virtual_SDR_Rx, '0', analog_nbfm_rx, '0']
- [wavfile_source, '0', control_volume, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
