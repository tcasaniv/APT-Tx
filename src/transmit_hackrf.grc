options:
  parameters:
    author: tcasaniv
    generate_options: qt_gui
    id: transmit_hackrf
    output_language: python
    title: transmit_hackrf
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '11025'
  states: {}
- name: fm_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: freq
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    gui_hint: 0,0,1,1
    lbl: Frecuencia de transmisión
    maxFreqHz: 1700e6
    minFreqHz: 88e6
    value: 928e6
  states: {}
- name: lna_sdr_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,1
    label: Ganancia LNA Tx | IF
    start: '0'
    step: '8'
    stop: '40'
    value: '0'
  states: {}
- name: vga_sdr_tx
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: Ganancia VGA Tx
    start: '0'
    step: '1'
    stop: '47'
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: Volumen
    start: '0'
    step: '1'
    stop: '300'
    value: '50'
  states: {}
- name: wav_path
  id: variable
  parameters:
    value: wavfile
  states: {}
- name: analog_nbfm_rx
  id: analog_nbfm_rx
  parameters:
    audio_rate: '12000'
    max_dev: 17e3
    quad_rate: int(fm_rate)
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx
  id: analog_nbfm_tx
  parameters:
    audio_rate: '12000'
    fh: '-1.0'
    max_dev: 17e3
    quad_rate: int(fm_rate)
    tau: '75e-6'
  states: {}
- name: audio_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: '12000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    type: float
  states: {state: disabled}
- name: audio_gui_time_sink
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '2048'
    srate: '12000'
    type: float
    update_time: '0.01'
  states: {state: disabled}
- name: audio_sink
  id: audio_sink
  parameters:
    samp_rate: '12000'
  states: {}
- name: control_volume
  id: blocks_multiply_const_vxx
  parameters:
    const: volume/100
    type: float
  states: {}
- name: detect_platform
  id: epy_module
  parameters:
    source_code: |-
      import platform
      from pathlib import Path

      APP_FILES_DIR_NAME = "APT-Tx_Files"

      def get_app_files_dir():
          """Obtiene la ruta a la carpeta de archivos de la aplicación y la crea si no existe."""
          if platform.system() == "Windows":
              base_path = Path(os.environ['USERPROFILE']) / 'Documents'
          else:
              base_path = Path.home()
          
          app_dir = base_path / APP_FILES_DIR_NAME
          app_dir.mkdir(parents=True, exist_ok=True)
          return str(app_dir)

      output_filename = f"apt_generated_audio.wav"
      generated_file_path = str(Path(get_app_files_dir()) / output_filename)
      wav_path = generated_file_path

      print(wav_path)
  states: {}
- name: fm_gui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_sdr
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    type: complex
  states: {}
- name: rational_resampler
  id: rational_resampler_xxx
  parameters:
    decim: int(fm_rate)
    interp: int(samp_rate_sdr)
    type: ccc
  states: {}
- name: rational_resampler_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: '12000'
    type: fff
  states: {}
- name: samp_rate_sdr
  id: parameter
  parameters:
    label: samp_rate_sdr
    short_id: s
    type: eng_float
    value: 8e6
  states: {}
- name: soapy_hackrf_sink
  id: soapy_hackrf_sink
  parameters:
    bandwidth: 1.75e6
    center_freq: freq
    samp_rate: samp_rate_sdr
    type: fc32
    vga: vga_sdr_tx
  states: {state: disabled}
- name: throttle_audio_gui
  id: blocks_throttle2
  parameters:
    samples_per_second: '12000'
    type: float
  states: {state: disabled}
- name: throttle_fm_gui
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_sdr
    type: complex
  states: {}
- name: virtual_SDR_Rx
  id: virtual_source
  parameters:
    stream_id: virtual_SDR
  states: {}
- name: virtual_SDR_Tx
  id: virtual_sink
  parameters:
    stream_id: virtual_SDR
  states: {}
- name: wavfile
  id: parameter
  parameters:
    label: wavfile
    short_id: f
    type: str
    value: detect_platform.wav_path
  states: {}
- name: wavfile_source
  id: blocks_wavfile_source
  parameters:
    file: wav_path
    repeat: 'True'
  states: {}

connections:
- [analog_nbfm_rx, '0', audio_sink, '0']
- [analog_nbfm_rx, '0', throttle_audio_gui, '0']
- [analog_nbfm_tx, '0', rational_resampler, '0']
- [analog_nbfm_tx, '0', soapy_hackrf_sink, '0']
- [analog_nbfm_tx, '0', virtual_SDR_Tx, '0']
- [control_volume, '0', rational_resampler_0, '0']
- [rational_resampler, '0', throttle_fm_gui, '0']
- [rational_resampler_0, '0', analog_nbfm_tx, '0']
- [throttle_audio_gui, '0', audio_gui_freq_sink, '0']
- [throttle_audio_gui, '0', audio_gui_time_sink, '0']
- [throttle_fm_gui, '0', fm_gui_freq_sink, '0']
- [virtual_SDR_Rx, '0', analog_nbfm_rx, '0']
- [wavfile_source, '0', control_volume, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
